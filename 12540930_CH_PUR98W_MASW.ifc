Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-01-22T14:24:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 22 14:24:23 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\96a95875-f9cb-46de-ba61-43f79637f9b6\0e0e0cc2-c3de-4c65-909b-486daed42154\ifc * Database version: 5507 * Database creation date: Mon Jan 22 14:24:22 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 22 14:24:23 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 22 14:24:23 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12540930_CH_PUR98W_MASW:28419855_CH_12540930_PUR98W_MASW, (2)
In: Default
Type - Classification: WAND-DEKOR DA (Uniformat); Material: z_Miele_Design_Glass
Type - Pset_BuildingElementProxyCommon - Reference: 28419855_CH_12540930_PUR98W_MASW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28419855_CH_12540930_PUR98W_MASW
Material: z_Miele_Design_Glass, Aluminum, z_Miele_Design_OBSW, z_Miele_Design_Steel_Chrom, z_Miele_Connection_ExhaustAir, z_Miele_Connection_Electric, z_Miele_Design_CLST
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 898 mm; Height: 62 mm; Depth: 500 mm
